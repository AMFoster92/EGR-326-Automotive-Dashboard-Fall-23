# Keil uVision project Final Project Slave.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final Project Slave
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c GPIOInit.c GPIOInit.h I2CSlave.c I2CSlave.h iLI9341.c iLI9341.h LED.c LED.h MAX7219.c MAX7219.h SPI.c SPI.h Timer.c Timer.h Watchdog.c Watchdog.h bitmap_typedefs.h ADC.h ADC.c Button.c Button.h BipolarStepperMotor.c BipolarStepperMotor.h
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.3
