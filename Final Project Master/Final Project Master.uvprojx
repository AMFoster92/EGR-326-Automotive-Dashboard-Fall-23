# Keil uVision project Final Project Master.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final Project Master
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c Button.h Debounce.h EEPROM.h Encoder.h GPIOInit.h HallEffect.h I2C.h RTC.h Sonar.h SysTick.h Timer.h UnipolarStepperMotor.h Watchdog.h Button.c Debounce.c EEPROM.c Encoder.c GPIOInit.c HallEffect.c I2C.c RTC.c Sonar.c SysTick.c Timer.c UnipolarStepperMotor.c Watchdog.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.3
